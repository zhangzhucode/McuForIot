# Keil uVision project stm32_zhang.uvproj, settings and files
target Standard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\Board\STM32\STM32F10x_StdPeriph_Driver\inc;..\..\..\Board\STM32\CMSIS\CM3\CoreSupport;..\..\..\Board\STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Board\STM32;..\..\..\Board\STM32\STM32_Devices;..\user;..\..\..\Rtos\ucos\config;..\..\..\Rtos\ucos\soc;..\..\..\dev\leds;..\..\..\dev\usb_devices;..\..\..\Board\STM32\STM32_USB-FS-Device_Driver\inc;..\..\..\Hal\Queue;..\..\..\dev\usb_mcuflash;..\..\..\dev\usb_vcom;..\..\..\dev\usb_mcuflash\inc;..\..\..\Board\STM32\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32CMSIS
    ../../../Board/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../../Board/STM32/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ../../../Board/STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32USBLIB
    ../../../Board/STM32/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32DEV
    ../../../Board/STM32/STM32_Devices/: cpu_id.c DriverConfig.c Printf.c RS232.c SPI1.c
  group UCOSII
    ../../../Rtos/ucos/config/: app_cfg.c os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../../../Rtos/ucos/soc/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group user
    ../user/: BSP_config.c DebugTask.c main.c stm32f10x_it.c system_stm32f10x.c UserappConfig.c
  group user_led
    ../../../dev/leds/: leddriver.c ledstask.c
  group USBD_usbdevices
    ../../../dev/usb_devices/: usb_devices.c
  group USBD_massflash
    ../../../dev/usb_mcuflash/: mass_hw_config.c mass_mal.c mass_memory.c mass_usb_bot.c mass_usb_desc.c mass_usb_endp.c mass_usb_istr.c mass_usb_prop.c mass_usb_pwr.c scsi_data.c scsi_usb.c usb_mcuflash_task.c
  group USBD_mouse
    ../../../dev/usb_mouse/: mouse_hw_config.c mouse_usb_desc.c mouse_usb_istr.c mouse_usb_prop.c mouse_usb_pwr.c usb_mouse_task.c
  group USBD_vcom
    ../../../dev/usb_vcom/: usb_vcom_task.c vcom_hw_config.c vcom_usb_desc.c vcom_usb_endp.c vcom_usb_istr.c vcom_usb_prop.c vcom_usb_pwr.c
  group Queue
    ../../../Hal/Queue/: Queue.c
