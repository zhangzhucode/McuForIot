# Keil uVision project project.uvproj, settings and files
target Standard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: leds +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\ucos\config;..\ucos\soc;.\USB_Module\Boad_conf;.\USB_Module\CH374_lib;.\USB_Module\USB_SYS;..\system;..\userapp;..\userdrivers\5110;..\userdrivers\Spi;..\userdrivers;..\userdrivers\MPU6050;..\userdrivers\5883l;..\leds;..\userdrivers\random
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../system/: system_stm32f10x.c BSP_config.c main.c stm32f10x_it.c
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Stm32_lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ucos_conf
    ../ucos/config/: os_dbg.c os_cpu_c.c app_cfg.c os_cpu_a.asm
  group ucos_soc
    ../ucos/soc/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group userdrivers
    ../userdrivers/5110/: nokia_5110.c 5110Task.c
    ../userdrivers/NRF24L01/: NRF24l01.c
    ../userdrivers/Spi/: SPI1.c
    ../userdrivers/: DriverConfig.c Printf.c RS232.c
    ../userdrivers/random/: random.c
  group userapp
    ../userapp/: DebugTask.c UserappConfig.c UserappConfig.h
  group MPU6050
    ../userdrivers/MPU6050/: MPU6050.c STM32_I2C.c MPU6050Task.c
  group HMC5883L
    ../userdrivers/5883l/: HMC5883l.c
  group leds
    ../leds/: leddriver.c ledstask.c
