# Keil uVision project stm32_zhang.uvproj, settings and files
target Standard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\ucos\config;.\USB_Module\Boad_conf;.\USB_Module\CH374_lib;.\USB_Module\USB_SYS;..\module\mpu6050;..\module\5110;..\userapp;..\stm32dev;..\stm32dev\Spi;..\module\ucos\soc;..\module\ucos\config;..\stm32lib\STM32F10x_StdPeriph_Driver\inc;..\stm32lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\stm32lib\CMSIS\CM3\CoreSupport;..\stm32lib\boot;..\module\leds;..\module\usb_mcuflash\inc;..\stm32lib\STM32_USB-FS-Device_Driver\inc;..\module\random;..\module
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32boot
    ../stm32lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../stm32lib/boot/: system_stm32f10x.c stm32f10x_it.c BSP_config.c main.c
  group stm32lib
    ../stm32lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../stm32lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../stm32lib/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group stm32dev
    ../stm32dev/: DriverConfig.c Printf.c RS232.c
    ../stm32dev/Spi/: SPI1.c
  group ucosII
    ../module/ucos/soc/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../module/ucos/config/: app_cfg.c os_cpu_c.c os_dbg.c os_cpu_a.asm
  group userapp
    ../userapp/: 5110Task.c DebugTask.c MPU6050Task.c UserappConfig.c
    ../module/: cpu_id.c
  group module_mpu6050
    ../module/mpu6050/: MPU6050.c STM32_I2C.c
  group module_hmc5883l
    ../module/hmc5883l/: HMC5883l.c
  group module_nrf24l01
    ../module/nrf24L01/: NRF24l01.c
  group module_5110
    ../module/5110/: nokia_5110.c
  group module_led
    ../module/leds/: leddriver.c ledstask.c
  group module_usbflash
    ../module/usb_mcuflash/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_mcuflash_task.c usb_prop.c usb_pwr.c usb_scsi.c
  group module_random
    ../module/random/: random.c
