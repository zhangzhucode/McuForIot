# Keil uVision project GONG_ZZ.uvprojx, settings and files
target Standard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GONG_ZZ +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\LIB\STM32F10x_StdPeriph_Driver\inc;.\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\ucos\config;.\ucos\soc;.\USB_Module\Boad_conf;.\USB_Module\CH374_lib;.\USB_Module\USB_SYS;.\Driver;.\Myproject;.\UserAPP;.\Driver\5110;.\Driver\Spi;.\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group RMV
    ./LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Myproject/: system_stm32f10x.c
  group Stm32_lib
    ./LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group ucos_conf
    ./ucos/config/: os_dbg.c os_cpu_c.c os_cpu_a.asm app_cfg.c
  group ucos_soc
    ./ucos/soc/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group Myproject
    ./Myproject/: stm32f10x_it.c BSP_config.c main.c
  group Driver
    ./Driver/: DriverConfig.h DriverConfig.c RS232.c Printf.c
    ./Driver/NRF24L01/: NRF24l01.c
    ./Driver/Spi/: SPI1.c
    ./Driver/5110/: nokia_5110.c
  group UserAPP
    ./UserAPP/: UserappConfig.h UserappConfig.c DebugTask.c 5110Task.c MPU6050Task.c
  group 6050
    ./MPU6050/: MPU6050.c STM32_I2C.c
  group HMC5883L
    ./5883l/: HMC5883l.c
software components: CMSIS:CORE 4.1.0
