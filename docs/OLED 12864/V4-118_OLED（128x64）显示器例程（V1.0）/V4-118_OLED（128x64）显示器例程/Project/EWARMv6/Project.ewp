# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User\app\inc; ..\..\User\fonts; ..\..\User\images; ..\..\User\uIP\uip; ..\..\User\uIP\http; ..\..\User\uIP\dm9000; ..\..\User\FatFS\src; ..\..\User\usb_mass; ..\..\User\CH376\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f3.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_ram.icf
  group App
    ../../User/app/src/: main.c
  group BSP
    ../../User/bsp/: bsp.c stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_key.c bsp_oled.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
